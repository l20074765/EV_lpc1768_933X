# Keil uVision project mVMC.uvprojx, settings and files
target EV_lpc1768_933X (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EV_lpc1768_933X_V1.5.hex +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Firmware\InChip.sct
  link misc: --entry __main
  group APP
    ./APP/: main.c Menu.c
    ./API/: mdbApi.c
  group API
    ./API/: hopperAPi.c displayApi.c task_dev.c billApi.c coinApi.c flashApi.c PcoinApi.c task_trade.c
  group DEVICE
    ./Drivers/: EVB.c RS232.c
  group DRIVERS
    ./Drivers/: uart0.c uart1.c uart2.c uart3.c buzzer.c display.c I2C.c timer.c key.c RTC.C board.c MDB.c
  group FIRMWARE
    ./Firmware/: LPC1700PinCfg.c target.c vector_table.c zy_if.c
  group STARTUP
    ./Startup/: rt_sys_c.c rt_sys_s.s
  group uCOS-II
    ./uCOS_II/cpu/: Os_cpu_c.c
    ./uCOS_II/hook/: uCOS-II hook.lib
    ./uCOS_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_TIME.C OS_TASK.C OS_SEM.C OS_Q.C OS_MUTEX.C
